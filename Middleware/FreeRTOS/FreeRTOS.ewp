# IAR project FreeRTOS.ewp, settings and files
configuration SWM231 (ARM, debug)
  General.OGChipSelectEditMenu: SWM231xB Synwit SWM231xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  ICCARM.CCIncludePath2: ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM231_StdPeriph_Driver\CSL\SWM231_StdPeriph_Driver; .\APP; .\APP\FreeRTOS\include; .\APP\FreeRTOS\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  AARM.AUserIncludes: .\APP
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/IAR/ARM_CM0/: portasm.s port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM231_StdPeriph_Driver/CSL/SWM231_StdPeriph_Driver/: SWM231_adc.c SWM231_exti.c SWM231_gpio.c SWM231_i2c.c SWM231_pwm.c SWM231_timr.c SWM231_uart.c SWM231_wdt.c SWM231_port.c SWM231_flash.c
  group CSL\CMSIS
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM231.c
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM231.s
