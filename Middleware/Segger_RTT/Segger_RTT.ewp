# IAR project Segger_RTT.ewp, settings and files
configuration SWM231 (ARM, debug)
  General.OGChipSelectEditMenu: SWM231xB Synwit SWM231xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  ICCARM.CCIncludePath2: ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM231_StdPeriph_Driver\CSL\SWM231_StdPeriph_Driver; .\APP\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  OBJCOPY.OOCOutputFile: Segger_RTT.srec
  ILINK.IlinkOutputFile: Segger_RTT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group RTT
    ./APP/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group CSL\StdPD
    ../../SWM231_StdPeriph_Driver/CSL/SWM231_StdPeriph_Driver/: SWM231_adc.c SWM231_exti.c SWM231_gpio.c SWM231_i2c.c SWM231_pwm.c SWM231_timr.c SWM231_uart.c SWM231_wdt.c SWM231_port.c SWM231_flash.c
  group CSL\CMSIS
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM231.c
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM231.s
