# Keil uVision project SPIFlash_NAND.uvprojx, settings and files
target SWM231 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM231x6 Synwit
  pack: Synwit.SWM32_New.0.2.5
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SPIFlash_NAND +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c define: CHIP_SWM231
  c include: ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM231_StdPeriph_Driver\CSL\SWM231_StdPeriph_Driver;.\APP
  asm define: CHIP_SWM231
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
    ./APP/: W25N01G.c
  group CSL\StdPD
    ../../SWM231_StdPeriph_Driver/CSL/SWM231_StdPeriph_Driver/: SWM231_adc.c SWM231_exti.c SWM231_gpio.c SWM231_i2c.c SWM231_pwm.c SWM231_timr.c SWM231_uart.c SWM231_wdt.c SWM231_port.c SWM231_spi.c SWM231_flash.c SWM231_can.c SWM231_div.c SWM231_dma.c SWM231_mpu.c SWM231_qei.c
  group CSL\CMSIS
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM231.c
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM231.s
