# IAR project SWM231_StdPeriph_Driver.ewp, settings and files
configuration SWM231 (ARM, debug)
  General.OGChipSelectEditMenu: SWM231xB Synwit SWM231xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM231_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM231
  OBJCOPY.OOCOutputFile: SWM231_StdPeriph_Driver.bin
  ILINK.IlinkOutputFile: SWM231_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    APP/: main.c
  group CSL\CMSIS
    CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM231.s
    CSL/CMSIS/DeviceSupport/: system_SWM231.c
  group CSL\StdPD
    CSL/SWM231_StdPeriph_Driver/: SWM231_adc.c SWM231_can.c SWM231_crc.c SWM231_div.c SWM231_dma.c SWM231_exti.c SWM231_flash.c SWM231_gpio.c SWM231_i2c.c SWM231_iofilt.c SWM231_mpu.c SWM231_port.c SWM231_pwm.c SWM231_qei.c SWM231_qspi.c SWM231_spi.c SWM231_timr.c SWM231_uart.c SWM231_usart.c SWM231_wdt.c
