# Keil uVision project SimplFLASH.uvprojx, settings and files
target SWM231 (6160000::V6.16::ARMCLANG)
  device: SWM231x6 Synwit
  pack: Synwit.SWM32_New.0.2.5
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplFLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CHIP_SWM231
  c include: ..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM231_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM231_StdPeriph_Driver\CSL\SWM231_StdPeriph_Driver
  asm define: CHIP_SWM231
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM231_StdPeriph_Driver/CSL/SWM231_StdPeriph_Driver/: SWM231_adc.c SWM231_exti.c SWM231_gpio.c SWM231_pwm.c SWM231_timr.c SWM231_uart.c SWM231_wdt.c SWM231_port.c SWM231_flash.c SWM231_div.c SWM231_dma.c SWM231_spi.c
  group CSL\CMSIS
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM231.c
    ../../SWM231_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM231.s
